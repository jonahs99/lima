## boards/shields/lima/Kconfig.defconfig
```kconfig
if SHIELD_LIMA

config ZMK_KEYBOARD_NAME
    default "lima"

endif # SHIELD_LIMA
```
